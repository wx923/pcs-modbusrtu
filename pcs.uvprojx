# Keil uVision project pcs.uvprojx, settings and files
target PCS (6210000::V6.21::ARMCLANG)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pcs
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F30X_HD, USE_STDPERIPH_DRIVER
  c include: .\APP;.\BSP;.\Drives\Firmware;.\Drives\Firmware\CMSIS\GD\GD32F30x\Include;.\Drives\Firmware\CMSIS\GD\GD32F30x\Source\ARM;.\Drives\Firmware\GD32F30x_standard_peripheral\Include;.\Services;.\Drives\Firmware\CMSIS;.\Drives\FreeRTOS-Kernel-main;.\Drives\FreeRTOS-Kernel-main\include;.\Drives\FreeRTOS-Kernel-main\portable\GCC\ARM_CM4F;.\BSP\Inc;.\Services\data;.\Services\protocol
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./APP/: gd32f30x.h gd32f30x_libopt.h main.c FreeRTOSConfig.h DSP_MasterTask.c MB_SlaveTask.c
  group BSP
    ./BSP/: bsp_init.c bsp_uart.c
  group Services
    ./Services/data/: dsp_mirror.c
    ./Services/protocol/: modbus_rtu.c
  group Startup
    ./Drives/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./Drives/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Frimwarm
    ./Drives/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group FreeRtos
    ./Drives/FreeRTOS-Kernel-main/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Drives/FreeRTOS-Kernel-main/portable/MemMang/: heap_4.c
    ./Drives/FreeRTOS-Kernel-main/portable/GCC/ARM_CM4F/: port.c
